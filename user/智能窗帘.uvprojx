# Keil uVision project 智能窗帘.uvprojx, settings and files
target 智能窗帘 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 智能窗帘 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\startup;..\system\delay;..\system\sys;..\system\usart;..\STM32F10x_FWLib\inc;..\ucosii\CONFIG;..\ucosii\CORE;..\ucosii\PORT;..\source\App;..\source\Init;..\source\Led;..\source\LCD;..\source\24Cxx;..\source\IIC;..\source\TOUCH;..\source\KEY;..\source\RTC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c system_stm32f10x.c
  group startup
    ../startup/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group source
    ../source/App/: app.c
    ../source/Init/: init.c
    ../source/Led/: led.c
    ../source/LCD/: ILI93xx.c lcd.c showCH.c showEN.c
    ../source/24Cxx/: 24Cxx.c
    ../source/IIC/: My_IIC.c
    ../source/TOUCH/: touch.c
    ../source/KEY/: key.c
    ../source/RTC/: rtc.c
  group ucosii\config
    ../ucosii/CONFIG/: includes.h os_cfg.h
  group ucosii\core
    ../ucosii/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucosii\port
    ../ucosii/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
